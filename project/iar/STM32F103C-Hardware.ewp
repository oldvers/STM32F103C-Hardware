# IAR project STM32F103C-Hardware.ewp, settings and files
configuration release (ARM)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: $HW_CFG_DIR$; $RTT_CFG_DIR$; ..\..\source; ..\..\source\cmsis\Include; ..\..\source\cmsis\Device\ST\STM32F1xx\Include; ..\..\source\hardware; ..\..\source\hardware\config; ..\..\source\rtt; ..\..\source\rtt\config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F103C8_BluePill.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../source/cmsis/Include/: core_cm3.h
    ../../source/cmsis/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xb.s
    ../../source/cmsis/Device/ST/STM32F1xx/Include/: stm32f103xb.h stm32f1xx.h system_stm32f1xx.h
    ../../source/cmsis/Device/ST/STM32F1xx/Source/Templates/iar/linker/: stm32f103xb_flash.icf
    ../../source/cmsis/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Hardware
    ../../source/hardware/config/: board.h
    ../../source/hardware/: debug.c debug.h gpio.c gpio.h i2c.c i2c.h interrupts.c interrupts.h spi.c spi.h system.c system.h types.h uart.c uart.h uniquedevid.h usb.c usb.h
  group RTT
    ../../source/rtt/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_printf.c
    ../../source/rtt/config/: SEGGER_RTT_Conf.h
