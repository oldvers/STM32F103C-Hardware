<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\submodule\cuties\project\iar\cuties.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\STM32F103C-Hardware.ewp</path>
    </project>
    <batchBuild />
</workspace>
