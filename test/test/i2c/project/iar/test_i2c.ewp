# IAR project test_i2c.ewp, settings and files
configuration test (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: $HW_CFG_DIR$; $RTT_CFG_DIR$; ..\..\..\..\..\submodule\cuties\source; ..\..\source; ..\..\..\..\..\source; ..\..\..\..\..\source\cmsis\Include; ..\..\..\..\..\source\cmsis\Device\ST\STM32F1xx\Include; ..\..\..\..\..\source\hardware; ..\..\..\..\..\source\hardware\config; ..\..\..\..\..\source\rtt; ..\..\..\..\..\source\rtt\config; ..\..\..\..\..\submodule\cuties\source\freertos; ..\..\..\..\..\submodule\cuties\source\freertos\Source\include; ..\..\..\..\..\submodule\cuties\source\freertos\Source\portable\IAR\ARM_CM3; ..\..\..\..\..\submodule\cuties\source\log
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F103C8_BluePill_Test_I2C.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\source\cmsis\Device\ST\STM32F1xx\Source\Templates\iar\linker\stm32f103xb_flash.icf
  ILINK.IlinkExtraOptions: --whole_archive ..\..\..\..\..\submodule\cuties\project\iar\build\release\exe\cuties.a; --whole_archive ..\..\..\..\..\project\iar\build\release\exe\STM32F103C-Hardware.a
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\submodule\cuties\project\iar\build\release\exe\cuties.a; ..\..\..\..\..\project\iar\build\release\exe\STM32F103C-Hardware.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Configuration
    ../../../../../configuration/: cuties_config.h hardware_config.h rtt_config.h
  group Main
    ../../../../source/: main.c
    ../../source/: mocks.c test.c
